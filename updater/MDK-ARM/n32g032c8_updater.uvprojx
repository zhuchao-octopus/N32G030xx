# Keil uVision project n32g032c8_updater.uvprojx, settings and files
target N32G032 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G032R8L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.1.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: n32g032c8_updater +hex
  AfterMake: fromelf --bin --output=.\bin\n32g032c8_updater.bin .\Objects\n32g032c8_updater.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER
  c include: ..\src;..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32g032_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x800e000 size 0x1c00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32g032.c
  group FWLB
    ../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_exti.c n32g032_flash.c n32g032_gpio.c n32g032_rcc.c n32g032_usart.c
  group USER
    ../src/: main.c n32g032_it.c systick.c iap.c
