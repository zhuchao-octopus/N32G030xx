# Keil uVision project n32g032c8_app.uvprojx, settings and files
target N32G032 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G032R8L7 Nationstech
  pack: Nationstech.N32G032_DFP.0.2.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: n32g032c8_app +hex
  AfterMake: fromelf --bin --output=.\bin\n32g032c8_app.bin .\Objects\n32g032c8_app.axf
  AfterMake: .\tools\make_ak_bin.bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G032, USE_STDPERIPH_DRIVER
  c include: ..\src;..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32g032_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32g032.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32g032.c
  group FWLB
    ../../firmware/n32g032_std_periph_driver/src/: misc.c n32g032_adc.c n32g032_exti.c n32g032_flash.c n32g032_gpio.c n32g032_pwr.c n32g032_rcc.c n32g032_rtc.c n32g032_tim.c n32g032_usart.c n32g032_wwdg.c
  group USER
    ../src/: beep.c channel.c Customer.C hal.c io.c led.c LinUart_Wince.c rds.c remote.c tda7708.c USART_Driver.C videochip.c audio_driver.c audio_eq.c bd37534.c bu32107.c Canbox.C Event.c key.c main.c n32g032_it.c power.c radio_driver.c system.c systick.c si4731.c si475x.c
